# Keil uVision project tem.uvprojx, settings and files
target tem (6210000::V6.21::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: tem +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/ATK_MS601M;../Drivers/BSP/Motor_Encoder;../Drivers/BSP/GanWei;../Drivers/Tracking;../Drivers/Mode;../Drivers/Visual;../Drivers/Kinematics_and_initialize;../Drivers/BSP/LED;../Drivers/BSP/HC05;../Drivers/BSP/OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/User/Core
    ../Core/Inc/: AllHeader.h
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers\BSP\ATK_MS601M
    ../Drivers/BSP/ATK_MS601M/: atk_ms601m.c atk_ms601m_uart.c
  group Drivers\BSP\Motor_Encoder
    ../Drivers/BSP/Motor_Encoder/: Hall_Encoder.c Mem.c tb6612fng.c
  group Drivers\BSP\GanWei
    ../Drivers/BSP/GanWei/: GanWei_i2c.c
  group Drivers\Tracking
    ../Drivers/Tracking/: tracking.c tracking_delay.c
  group Drivers\Mode
    ../Drivers/Mode/: mode.c
  group Drivers\Visual
    ../Drivers/Visual/: visual.c
  group Drivers\Kinematics_Initialize
    ../Drivers/Kinematics_and_initialize/: Initialize.c kinematics.c
  group Drivers\BSP\LED
    ../Drivers/BSP/LED/: led.c
  group Drivers\BSP\Bluetooth
    ../Drivers/BSP/HC05/: Bluetooth.c
  group Drivers\BSP\OLED
    ../Drivers/BSP/OLED/: oled.c
software components: CMSIS:CORE 5.1.2
